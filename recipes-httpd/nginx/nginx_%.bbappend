SUMMARY = "Honda NGINX configuration"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
